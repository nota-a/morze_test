# Keil uVision project ksc_test.uvprojx, settings and files
target Target 1 (6190000::V6.19::ARMCLANG)
  device: MDR1986BE92 Milandr
  pack: Keil.MDR1986BExx.2.0.3
  cpu: IRAM(0x20000000,0x8000) IROM(0x08000000,0x20000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: ksc_test
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=3
  c include: .\milandr-standard-peripherals-library\src\MDR32F9Qx_StdPeriph_Driver\inc
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group inc
    ./: main.h
  group src
    ./: main.c
    ./milandr-standard-peripherals-library/src/MDR32F9Qx_StdPeriph_Driver/src/: MDR32F9Qx_port.c MDR32F9Qx_rst_clk.c MDR32F9Qx_uart.c
software components: CMSIS:CORE 6.1.0, Device:Startup 2.0.3
